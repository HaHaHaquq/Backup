# Keil uVision project RF_Tester_DUT_916.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: ING91600 INGChips
  pack: INGChips.INGCHIPS_DeviceFamilyPack.0.9.0
  cpu: IROM(0x2000000-0x21fffff) IRAM(0x20000000-0x20007fff) CPUTYPE("Cortex-M4") FPU2 CLOCK(12800000) ELITTLE
  output: RF_Tester_DUT_916 +hex
  AfterMake: fromelf.exe --bin -o RF_Tester_DUT_916.bin ./output/RF_Tester_DUT_916.axf
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER
  c include: sdk/bundles/noos_extension/inc;sdk/bundles/noos_extension/inc/os;sdk/src/BSP;sdk/src/FWlib;sdk/src/StartUP/ing916;sdk/src/Tools;sdk/src
  library: MicroLIB
  memory RVCT4: ROM 0x2029000 size 0x57000
  memory RVCT9: RAM 0x20000c68 size 0x7398
  group APP
    ./src/: main.c profile.c pulse_test_gpio.c noos_impl.c
  group StartUP
    ./src/: startup_ing91600.s
    sdk/bundles/noos_extension/ING9168xx/: symdefs.m
  group BSP
    sdk/src/BSP/: eflash.c
  group FWlib
    sdk/src/FWlib/: peripheral_adc.c peripheral_gpio.c peripheral_i2c.c peripheral_pinctrl.c peripheral_pwm.c peripheral_rtc.c peripheral_ssp.c peripheral_sysctrl.c peripheral_timer.c peripheral_uart.c peripheral_comparator.c peripheral_dma.c peripheral_efuse.c peripheral_i2s.c peripheral_ir.c peripheral_keyscan.c peripheral_pdm.c peripheral_pte.c peripheral_qdec.c peripheral_usb.c
  group Tools
    sdk/src/Tools/: trace.c
  group Rf_Test
    ./src/: filter.c raw_pkt.c rf_test.c
  group uart protocol
    ./src/: freq_offset.c crc_16.c my_ring_buffer.c uart_golden_DUT.c
software components: CMSIS:CORE 4.3.0
