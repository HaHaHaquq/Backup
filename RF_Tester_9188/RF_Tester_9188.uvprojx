# Keil uVision project RF_Tester_9188.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: ing91800 INGChips
  pack: INGChips.INGCHIPS_DeviceFamilyPack.0.9.0
  cpu: CLOCK(32000000) CPUTYPE("Cortex-M3") ELITTLE IROM(0x4000-0x43fff) IRAM(0x20000000-0x2000ffff)
  output: RF_Tester_9188 +hex
  AfterMake: fromelf.exe --bin -o RF_Tester_9188.bin ./output/RF_Tester_9188.axf
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER
  c include: sdk/bundles/noos_extension/inc;sdk/bundles/noos_extension/inc/os;sdk/src/BSP;sdk/src/FWlib;sdk/src/StartUP/ing918;sdk/src/Tools;sdk/src;.\src
  library: MicroLIB
  memory RVCT4: ROM 0x26000 size 0x5e000
  memory RVCT9: RAM 0x20000ce0 size 0xf320
  group APP
    ./src/: main.c profile.c noos_impl.c freq_offest.c rf_test.c tx_rx_test.c uart_golden_DUT.c uart_ota.c uart_upper_golden.c pulse_test_gpio.c flash_fun.c uart_driver.c sw_gpio.c amo_ctrl.c
  group StartUP
    ./src/: startup_ing91800.s
    sdk/bundles/noos_extension/ING9188xx/: symdefs.m
  group BSP
    sdk/src/BSP/: eflash.c
  group FWlib
    sdk/src/FWlib/: peripheral_adc.c peripheral_gpio.c peripheral_i2c.c peripheral_pinctrl.c peripheral_pwm.c peripheral_rtc.c peripheral_ssp.c peripheral_sysctrl.c peripheral_timer.c peripheral_uart.c peripheral_comparator.c peripheral_dma.c peripheral_efuse.c peripheral_i2s.c peripheral_ir.c peripheral_keyscan.c peripheral_pdm.c peripheral_pte.c peripheral_qdec.c peripheral_usb.c
  group Tools
    sdk/src/Tools/: trace.c
software components: CMSIS:CORE 4.3.0
